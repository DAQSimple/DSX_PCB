# Repository DAQSimple/DSX_PCB

File README.md:

<!-- PROJECT SHIELDS -->
<!--
-->

<!-- PROJECT LOGO -->
<br />
<p align="center">

  <h3 align="center">DSX Safe Data Acquisition System</h3>

  <p align="center">
    An open source, safe, and general purpose DAQ card for university students! 
    <br />
  </p>
</p>

<!-- TABLE OF CONTENTS -->
<details open="open">
  <summary>Table of Contents</summary>
  <ol>
    <li>
      <a href="#about-the-project">About The Project</a>
    </li>
    <li>
      <a href="#getting-started">Getting Started</a>
      <ul>
        <li><a href="#prerequisites">Prerequisites</a></li>
        <li><a href="#installation">Installation</a></li>
      </ul>
    </li>
    <li><a href="#usage">Usage</a></li>
    <li><a href="#roadmap">Roadmap</a></li>
  </ol>
</details>

<!-- ABOUT THE PROJECT -->
## About The Project

This is for the DSX Shield PCB that will contain our safety circuits and hardware interface for the end user. The PCB is designed in Autodesk Eagle.
The aim of this product is to assist university engineering students with their projects in fields such as robotics, control, and data acquisition. 

Main Features:
* Over current & over votage detection through interrupts 
* Interfaces with Matlab Simulink
* Modularized code base for easy contributing

This is a capstone project that started in January 2021 with the goal of integrating into a pick and place robotic arm project.
Thanks to all the developers who are contributing to this project and helping it grow.

<!-- GETTING STARTED -->
## Getting Started

Follow the steps below to start developing on the firmware.

### Prerequisites

Install the following
* [AutoDesk Eagle](https://www.autodesk.ca/en/products/eagle/free-download)
* [AutoDesk Fusion 360](https://www.autodesk.ca/en/products/fusion-360/free-trial)

### Installation

1. Clone the repo
   ```sh
   git clone https://github.com/DAQSimple/DSX_PCB
   ```
2. cd into the working directory
   ```sh
   cd DSX_PCB
   ```

<!-- USAGE EXAMPLES -->
## Usage

Use this space to show useful examples of how a project can be used. Additional screenshots, code examples and demos work well in this space. You may also link to more resources.

_For more examples, please refer to the [Documentation](https://drive.google.com/drive/u/0/folders/1v6Ogk9cWeK-9JGX7ApI4z3O4f6FaFJ_J)_

<!-- CONTRIBUTING -->
## Contributing

The collaborate development model being used in this project is shared repository

1. Create your Feature Branch (`git checkout -b feature/AmazingFeature`)
2. Commit your Changes (`git commit -m 'Add some AmazingFeature'`)
3. Push to the Branch (`git push origin feature/AmazingFeature`)
4. Open a Pull Request
5. Wait for merge

<!-- Git GUI -->
## Git GUI

If you prefer working with git on a GUI instead of the command line terminal, you can try using the following:

* [GitHub Desktop](https://desktop.github.com/)
* [Git Kraken](https://www.gitkraken.com/)

## EAGLE design DSX_PCB/DSX_schematic.brd

Parts:
J1, J2: FE02-11X02-3D; HDRVR2W64P254_1X2_558X254X850B
J3: 1X18-MALE-RECEPTACLE-LEFT1X18LREC; HDRRA18W100P504_1X18_9232X254X556B
J4, J5: FE19-2FE02-19-HEADER-3D; HDRVR38W64P254_2X19_4876X508X850B
J6, J9: FE08-11X8-FEM-HEAD-3D; HDRVR8W64P254_1X8_2082X254X850B
J7: FE10-11X10-FEM-HEAD-3D; HDRVR10W64P254_1X10_2590X254X850B
J8: FE06-11X6-FEM-HEAD; HDRVR6W64P254_1X6_1574X254X850B
J10: 1X18-MALE-RECEPTACLE-RIGHT1X18RREC; HDRRA18W100P508_1X18_9304X254X556B

Connections:
+3V3: J3.1, J4.16, J6.4, J10.18; also elsewhere on the board
+5V: J3.2, J4.18, J6.5, J10.17
ADC_CURRENT: J5.18; also elsewhere on the board
AI1_M: J4.28; also elsewhere on the board
AI1_T: J3.13; also elsewhere on the board
AI2_M: J4.30; also elsewhere on the board
AI2_T: J3.12; also elsewhere on the board
AI3_M: J4.38; also elsewhere on the board
AI3_T: J3.11; also elsewhere on the board
AI4_M: J4.36; also elsewhere on the board
AI4_T: J3.10; also elsewhere on the board
AO1_M: J4.32; also elsewhere on the board
AO1_T: J3.8; also elsewhere on the board
AO2_M: J5.11; also elsewhere on the board
AO2_T: J3.6; also elsewhere on the board
DI1_M: J5.37; also elsewhere on the board
DI1_T: J10.2; also elsewhere on the board
DI2_M: J5.35; also elsewhere on the board
DI2_T: J10.3; also elsewhere on the board
DI3_M: J5.33; also elsewhere on the board
DI3_T: J10.4; also elsewhere on the board
DI4_M: J5.31; also elsewhere on the board
DI4_T: J10.5; also elsewhere on the board
DI5_M: J5.29; also elsewhere on the board
DI5_T: J10.6; also elsewhere on the board
DI6_M: J5.27; also elsewhere on the board
DI6_T: J10.7; also elsewhere on the board
DLED1: J5.30; also elsewhere on the board
DLED2: J5.28; also elsewhere on the board
DLED3: J5.26; also elsewhere on the board
DO1_M: J5.17; also elsewhere on the board
DO1_T: J10.10; also elsewhere on the board
DO2_M: J5.19; also elsewhere on the board
DO2_T: J10.11; also elsewhere on the board
ENCA_M: J5.14; also elsewhere on the board
ENCA_T: J10.14; also elsewhere on the board
ENCB_M: J5.12; also elsewhere on the board
ENCB_T: J10.15; also elsewhere on the board
FAULT_LED: J4.37; also elsewhere on the board
GND: J3.5, J3.7, J3.9, J3.14, J4.8, J4.19, J4.20, J4.22, J5.9, J5.20, J6.6, J6.7, J7.7, J10.1, J10.16; also elsewhere on the board
I2CSDA_M: J3.4, J5.5
I2CSLC_M: J3.3, J5.3
LS1_M: J5.23; also elsewhere on the board
LS1_T: J10.8; also elsewhere on the board
LS2_M: J5.25; also elsewhere on the board
LS2_T: J10.9; also elsewhere on the board
MUXA_S0: J5.24; also elsewhere on the board
MUXA_S1: J5.22; also elsewhere on the board
MUXA_S2: J5.16; also elsewhere on the board
MUXA_S3: J5.4; also elsewhere on the board
MUXB_S0: J5.2; also elsewhere on the board
MUXC_S0: J5.1; also elsewhere on the board
MUX_EN: J4.17; also elsewhere on the board
PWM1_M: J5.13; also elsewhere on the board
PWM1_T: J10.12; also elsewhere on the board
PWM2_M: J5.15; also elsewhere on the board
PWM2_T: J10.13; also elsewhere on the board
RESET: J4.14; also elsewhere on the board
SPICS_M: J3.15, J4.23
SPIMISO_M: J3.17, J4.2
SPIMOSI_M: J3.18, J4.3
SPISCK_M: J3.16, J4.1

Notes on the sheet:
DSX Shield Main
Revision 2.0

Parts:
FAULT_LED+: SOLDERPAD; LSP10
FAULT_LED-: SOLDERPAD; LSP10
LD1, LD2, LD3: GREEN-LED-SMT; R0603
PWR_GOOD_LED+: SOLDERPAD; LSP10
PWR_GOOD_LED-: SOLDERPAD; LSP10
R1: 54.9R; R0805
R2: 100R; R0805
R3: 4k7; R0805
R4, R8, R12: 36R; R0805
R20, R25, R32, R39, R46, R52, R57, R61, R65, R69, R73: 1R; R0805
R26, R33, R40, R44, R50, R55, R59, R63, R67, R71, R75, R79: 10k; R0805
R27, R34, R41, R45: 300R; R0805
R51, R53, R56, R58, R60, R62, R64, R66, R68, R70, R72, R74, R76, R78, R80, R82: 160R; R0805
R77: 1R\; R0805
RESET_SW+: SOLDERPAD; LSP10
RESET_SW-: SOLDERPAD; LSP10
U15, U16, U17: ILQ615-4ILQ615; DIP762W53P254L1992H508Q16B

Connections:
+3V3: R2.1, R3.2, U15.10 (CO4), U15.12 (CO3), U15.14 (CO2), U15.16 (CO1), U16.10 (CO4), U16.12 (CO3), U16.14 (CO2), U16.16 (CO1), U17.10 (CO4), U17.12 (CO3), U17.14 (CO2), U17.16 (CO1); also elsewhere on the board
DI1_M: R79.1, U15.15 (E1); also elsewhere on the board
DI1_T: U15.1 (A1); also elsewhere on the board
DI2_M: R75.1, U15.13 (E2); also elsewhere on the board
DI2_T: U15.3 (A2); also elsewhere on the board
DI3_M: R71.1, U15.11 (E3); also elsewhere on the board
DI3_T: U15.5 (A3); also elsewhere on the board
DI4_M: R67.1, U15.9 (E4); also elsewhere on the board
DI4_T: U15.7 (A4); also elsewhere on the board
DI5_M: R63.1, U16.15 (E1); also elsewhere on the board
DI5_T: U16.1 (A1); also elsewhere on the board
DI6_M: R59.1, U16.13 (E2); also elsewhere on the board
DI6_T: U16.3 (A2); also elsewhere on the board
DLED1: R12.1; also elsewhere on the board
DLED2: R8.1; also elsewhere on the board
DLED3: R4.1; also elsewhere on the board
DO1_M: U17.1 (A1); also elsewhere on the board
DO1_T: R39.2; also elsewhere on the board
DO2_M: U17.3 (A2); also elsewhere on the board
DO2_T: R32.2; also elsewhere on the board
FAULT_LED: R1.1; also elsewhere on the board
GND: FAULT_LED-.MP, LD1.2 (C), LD2.2 (C), LD3.2 (C), PWR_GOOD_LED-.MP, R26.2, R27.1, R33.2, R34.1, R40.2, R41.1, R44.2, R45.1, R50.2, R53.1, R55.2, R58.1, R59.2, R62.1, R63.2, R66.1, R67.2, R70.1, R71.2, R74.1, R75.2, R78.1, R79.2, R82.1, RESET_SW-.MP; also elsewhere on the board
LMA0: R77.1, R82.2; also elsewhere on the board
LMA1: R73.1, R78.2; also elsewhere on the board
LMA2: R69.1, R74.2; also elsewhere on the board
LMA3: R65.1, R70.2; also elsewhere on the board
LMA4: R61.1, R66.2; also elsewhere on the board
LMA5: R57.1, R62.2; also elsewhere on the board
LMA6: R52.1, R58.2; also elsewhere on the board
LMA7: R46.1, R53.2; also elsewhere on the board
LMA8: R39.1, R44.1, U17.15 (E1); also elsewhere on the board
LMA9: R32.1, R40.1, U17.13 (E2); also elsewhere on the board
LMA10: R25.1, R33.1, U17.11 (E3); also elsewhere on the board
LMA11: R20.1, R26.1, U17.9 (E4); also elsewhere on the board
LS1_M: R55.1, U16.11 (E3); also elsewhere on the board
LS1_T: U16.5 (A3); also elsewhere on the board
LS2_M: R50.1, U16.9 (E4); also elsewhere on the board
LS2_T: U16.7 (A4); also elsewhere on the board
unnamed: R51.2, U16.8 (C4)
unnamed: R56.2, U16.6 (C3)
unnamed: R45.2, U17.2 (C1)
unnamed: R41.2, U17.4 (C2)
unnamed: R60.2, U16.4 (C2)
unnamed: R64.2, U16.2 (C1)
unnamed: R80.2, U15.2 (C1)
unnamed: R76.2, U15.4 (C2)
unnamed: LD3.1 (A), R12.2
unnamed: LD2.1 (A), R8.2
unnamed: LD1.1 (A), R4.2
unnamed: FAULT_LED+.MP, R1.2
unnamed: PWR_GOOD_LED+.MP, R2.2
unnamed: R72.2, U15.6 (C3)
unnamed: R68.2, U15.8 (C4)
unnamed: R27.2, U17.8 (C4)
unnamed: R34.2, U17.6 (C3)
PWM1_M: U17.5 (A3); also elsewhere on the board
PWM1_T: R25.2; also elsewhere on the board
PWM2_M: U17.7 (A4); also elsewhere on the board
PWM2_T: R20.2; also elsewhere on the board
RESET: R3.1, RESET_SW+.MP; also elsewhere on the board
RMA0: R77.2, R80.1; also elsewhere on the board
RMA1: R73.2, R76.1; also elsewhere on the board
RMA2: R69.2, R72.1; also elsewhere on the board
RMA3: R65.2, R68.1; also elsewhere on the board
RMA4: R61.2, R64.1; also elsewhere on the board
RMA5: R57.2, R60.1; also elsewhere on the board
RMA6: R52.2, R56.1; also elsewhere on the board
RMA7: R46.2, R51.1; also elsewhere on the board

Notes on the sheet:
GPIO
DEBUG LEDS
FRONT PANEL
DIGITAL INPUTS
DIGITAL OUTPUTS

Parts:
C1, C2: 10uF; E5-4
IC1: TL7660P; DIL08
R5, R6, R11, R37: 100R; R0805
R7, R10, R13, R14, R16, R17, R24, R30: 10k; R0805
R9, R15, R18, R19, R31, R84: 1R; R0805
R38, R85: 3k3; R0805
R48, R81: 2k; R0805
R49, R87: 6k65; R0805
R54, R86: 1k; R0805
R83, R88: 220R; R0805
U1, U2, U3, U5, U8, U9: OPAMP-SOT23OPAMP-SOT23-3D; SOT95P240X110-5N
Z1, Z2, Z3, Z4, Z5, Z6, Z7, Z8, Z9, Z10: 3V3-ZENERZENER-SOT23-3D; SOT95P230X110-3N

Connections:
+3V3: IC1.8 (VCC), R7.1, R10.1, R14.1, R30.1, U1.2 (V+), U2.2 (V+), U3.2 (V+), U5.2 (V+), U8.2 (V+), U9.2 (V+); also elsewhere on the board
-3V3: C2.-, IC1.5 (VOUT), R49.2, R87.2, U5.5 (V-), U9.5 (V-); also elsewhere on the board
AI1_M: U8.1 (OUT), U8.4 (-IN); also elsewhere on the board
AI1_T: R37.1; also elsewhere on the board
AI2_M: U3.1 (OUT), U3.4 (-IN); also elsewhere on the board
AI2_T: R11.1; also elsewhere on the board
AI3_M: U1.1 (OUT), U1.4 (-IN); also elsewhere on the board
AI3_T: R5.1; also elsewhere on the board
AI4_M: U2.1 (OUT), U2.4 (-IN); also elsewhere on the board
AI4_T: R6.1; also elsewhere on the board
AO1_M: R85.1; also elsewhere on the board
AO1_T: R84.1; also elsewhere on the board
AO2_M: R38.1; also elsewhere on the board
AO2_T: R31.1; also elsewhere on the board
ENCA_M: R83.2, Z9.3 (C); also elsewhere on the board
ENCA_T: R83.1; also elsewhere on the board
ENCB_M: R88.2, Z10.3 (C); also elsewhere on the board
ENCB_T: R88.1; also elsewhere on the board
GND: C2.+, IC1.3 (GND), R54.2, R86.2, U1.5 (V-), U2.5 (V-), U3.5 (V-), U8.5 (V-), Z1.1 (A), Z4.1 (A), Z6.1 (A), Z7.1 (A), Z9.1 (A), Z10.1 (A); also elsewhere on the board
LMA12: R19.2, R24.1, R37.2; also elsewhere on the board
LMA13: R11.2, R17.1, R18.2; also elsewhere on the board
LMA14: R5.2, R9.2, R13.1; also elsewhere on the board
LMA15: R6.2, R15.2, R16.1; also elsewhere on the board
LMB0: R81.1, R84.2, U5.1 (OUT); also elsewhere on the board
LMB1: R31.2, R48.1, U9.1 (OUT); also elsewhere on the board
unnamed: R24.2, R30.2, U8.3 (+IN)
unnamed: Z4.3 (C), Z8.3 (C)
unnamed: Z3.3 (C), Z7.3 (C)
unnamed: R7.2, R17.2, U3.3 (+IN)
unnamed: C1.-, IC1.4 (CAP-)
unnamed: C1.+, IC1.2 (CAP+)
unnamed: Z1.3 (C), Z5.3 (C)
unnamed: R13.2, R14.2, U1.3 (+IN)
unnamed: Z2.3 (C), Z6.3 (C)
unnamed: R10.2, R16.2, U2.3 (+IN)
unnamed: R81.2, R86.1, U5.4 (-IN)
unnamed: R85.2, R87.1, U5.3 (+IN)
unnamed: R48.2, R54.1, U9.4 (-IN)
unnamed: R38.2, R49.1, U9.3 (+IN)
RMA12: R19.1, Z8.1 (A); also elsewhere on the board
RMA13: R18.1, Z3.1 (A); also elsewhere on the board
RMA14: R9.1, Z5.1 (A); also elsewhere on the board
RMA15: R15.1, Z2.1 (A); also elsewhere on the board

Notes on the sheet:
Analog
-3V3 GENERATOR
ANALOG INPUTS
ANALOG OUTPUTS
ENCODER CHANNEL A AND B INPUTS

Parts:
R21, R22: 10k; R0805
R23, R28, R29, R36: 56.2k; R0805
R35, R42, R43, R47: 1k; R0805
U4, U6, U7: OPAMP-SOT23OPAMP-SOT23-3D; SOT95P240X110-5N
U10, U11, U12: 2CH_ANALOG_MUX2CH-MUX-SSOP8; SOP50P310X100-8N
U13, U14: 16CH_ANALOG_MUX; SOP65P640X110-24N

Connections:
+3V3: R22.1, U4.2 (V+), U6.2 (V+), U7.2 (V+), U10.8 (VCC), U11.8 (VCC), U12.8 (VCC), U13.24 (VCC), U14.24 (VCC); also elsewhere on the board
-3V3: U4.5 (V-), U6.5 (V-); also elsewhere on the board
ADC_CURRENT: U7.1 (OUT), U7.4 (-IN); also elsewhere on the board
AO1_T: U11.6 (Y1); also elsewhere on the board
AO2_T: U11.7 (Y0); also elsewhere on the board
DO1_T: U14.23 (Y8); also elsewhere on the board
DO2_T: U14.22 (Y9); also elsewhere on the board
GND: R23.2, R29.2, U7.5 (V-), U10.3 (GND), U10.4 (GND), U11.3 (GND), U11.4 (GND), U12.3 (GND), U12.4 (GND), U13.12 (GND), U14.12 (GND); also elsewhere on the board
LMA0: U13.9 (Y0); also elsewhere on the board
LMA1: U13.8 (Y1); also elsewhere on the board
LMA2: U13.7 (Y2); also elsewhere on the board
LMA3: U13.6 (Y3); also elsewhere on the board
LMA4: U13.5 (Y4); also elsewhere on the board
LMA5: U13.4 (Y5); also elsewhere on the board
LMA6: U13.3 (Y6); also elsewhere on the board
LMA7: U13.2 (Y7); also elsewhere on the board
LMA8: U13.23 (Y8); also elsewhere on the board
LMA9: U13.22 (Y9); also elsewhere on the board
LMA10: U13.21 (Y10); also elsewhere on the board
LMA11: U13.20 (Y11); also elsewhere on the board
LMA12: U13.19 (Y12); also elsewhere on the board
LMA13: U13.18 (Y13); also elsewhere on the board
LMA14: U13.17 (Y14); also elsewhere on the board
LMA15: U13.16 (Y15); also elsewhere on the board
LMB0: U12.6 (Y1); also elsewhere on the board
LMB1: U12.7 (Y0); also elsewhere on the board
MUXA_S0: U13.10 (S0), U14.10 (S0); also elsewhere on the board
MUXA_S1: U13.11 (S1), U14.11 (S1); also elsewhere on the board
MUXA_S2: U13.14 (S2), U14.14 (S2); also elsewhere on the board
MUXA_S3: U13.13 (S3), U14.13 (S3); also elsewhere on the board
MUXB_S0: U11.5 (S), U12.5 (S); also elsewhere on the board
MUXC_S0: U10.5 (S); also elsewhere on the board
MUX_EN: U10.2 (!E), U11.2 (!E), U12.2 (!E), U13.15 (!EN), U14.15 (!EN); also elsewhere on the board
unnamed: R42.1, U12.1 (Z)
unnamed: R43.1, U13.1 (Z)
unnamed: R36.1, R47.2, U6.4 (-IN)
unnamed: R28.1, R35.2, U4.4 (-IN)
unnamed: R28.2, U4.1 (OUT), U10.6 (Y1)
unnamed: R36.2, U6.1 (OUT), U10.7 (Y0)
unnamed: R21.2, R22.2, U7.3 (+IN)
unnamed: R23.1, R42.2, U6.3 (+IN)
unnamed: R47.1, U11.1 (Z)
unnamed: R35.1, U14.1 (Z)
unnamed: R21.1, U10.1 (Z)
unnamed: R29.1, R43.2, U4.3 (+IN)
PWM1_T: U14.21 (Y10); also elsewhere on the board
PWM2_T: U14.20 (Y11); also elsewhere on the board
RMA0: U14.9 (Y0); also elsewhere on the board
RMA1: U14.8 (Y1); also elsewhere on the board
RMA2: U14.7 (Y2); also elsewhere on the board
RMA3: U14.6 (Y3); also elsewhere on the board
RMA4: U14.5 (Y4); also elsewhere on the board
RMA5: U14.4 (Y5); also elsewhere on the board
RMA6: U14.3 (Y6); also elsewhere on the board
RMA7: U14.2 (Y7); also elsewhere on the board
RMA12: U14.19 (Y12); also elsewhere on the board
RMA13: U14.18 (Y13); also elsewhere on the board
RMA14: U14.17 (Y14); also elsewhere on the board
RMA15: U14.16 (Y15); also elsewhere on the board

Notes on the sheet:
Current Sensing

Board: 2 copper layers, 97.0 x 97.0 mm, 137 parts (0 on the bottom side), 136 nets.

## Commit log

2021-06-10 Initialize empty pcb project, no board yet
2021-06-10 Add empty DSX component library
2021-06-12 Add Frame
2021-06-12 Empty PCB
2021-06-12 Add more sheets
2021-06-12 Add GPIO, Analog, Current sense sheet, and start header
2021-06-14 DSX library progress
2021-06-14 Add more components and 3D packages for em
2021-06-14 headers and conns sorta in place now
2021-06-15 Headers for nucleo in position
2021-06-15 now the headers are aligned
2021-06-16 Digital Inputs
    FIX EVERYTHING JAY
2021-06-16 fix header misalignment -jay
2021-06-18 DI, DO, AI, Most of AO Schematic Completed
2021-06-19 Schematic Only Completed Excluding Current Sensing
2021-06-19 Fixed Missing Terminal Defines
2021-06-19 Completed Schematic and Routing (Excluding Current Sensing)
2021-06-20 Finish connecting current sensing circuits. Didn't organize board.
2021-06-20 Modified DO circuit and started autorouting
    - Routing is not complete
    - May need to do a fresh auto route again
2021-06-20 Commit before replacing left and right receptacles with correct size 3D package
2021-06-20 3D models done. PCB layout updated. No routing.
2021-06-22 Adjusted Resistor values
    - Digital input resistors 100R to 160R
    - Digital output LED resistor to 300R
    - Debug LED resistor to 5.6R
2021-06-22 Fix limit switch in wrong pins and flipped J8
2021-06-22 did stuff
2021-06-23 Added test points
2021-06-23 ERC on schematic done
2021-06-23 DRC with JLCPCB 2 layer dru done
2021-06-23 Autorouted 100%
2021-06-23 Optimize component placement. Verified nucleo header positions
2021-06-23 Add placement guides for IC1 and debug LEDs
2021-06-24 Change 5V to 3V3 for MUX vcc
    Cant use 5V vcc since then our 3V3 digital inputs wont work with their CMOS levels with 5V vcc
2021-07-02 rev2 initial changes
    - replaced buffers for encoder inputs with resistor 3V3 zener
    - Redefined ADC_CURRENT pin
    - Defined ENCA_M and ENCB_M
2021-07-11 Changes
    - Replaced -3V3 Generator with THT version
    - Replaced smd caps with tht caps
    - change debug led resistances to 36R so its not so bright
2021-07-11 respositioned j6 and j8
2021-07-11 Replaced previous test points with vias
2021-07-11 more changes
2021-07-11 I2C and SPI direct from MCU to terminals
2021-07-11 Moved resistors and stuff
2021-07-11 Generated gerber
